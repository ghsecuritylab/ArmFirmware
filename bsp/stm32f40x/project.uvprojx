# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f4xx (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER, EEG
  c misc: --c99
  c include: .;..\..\components\drivers\include;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;Libraries\CMSIS\Include;Libraries\CMSIS\ST\STM32F4xx\Include;Libraries\STM32F4xx_StdPeriph_Driver\inc;applications;drivers;.\RS9110-N-11-22-04\api;.\RS9110-N-11-22-04\config;..\..\components\dfs\include;.\ch37x;..\..\components\drivers\include\drivers;.\testcase;.\ads1299_driver;.\1-wire_driver\common;.\1-wire_driver\lib\ds28e80;.\1-wire_driver\lib\ds2401;.\drivers\dcDisplayer;.\drivers\ch37x
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c startup.c
    ./applications/: delay.c key_scan.c
    ./: tfcard.c
  group Drivers
    drivers/: board.c stm32f4xx_it.c usart.c gpio.c
    ./drivers/: spi.c exti.c bsp_internalFlash.c adc.c led.c stm32f4_rtc.c fonts.c gl823k.c
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_pwr.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../../components/drivers/rtc/: rtc.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Testcase
    ./testcase/: testcase.c
  group dcDisplayer
    ./drivers/dcDisplayer/: cmd_process.c cmd_queue.c hmi_driver.c hmi_user_uart.c ulitity.c usart4.c
  group ch378
    ./drivers/ch37x/: ch378.c ch378_file_sys.c ch378_sys.c
